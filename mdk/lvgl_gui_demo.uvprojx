# Keil uVision project lvgl_gui_demo.uvprojx, settings and files
target lvgl_demo sdram_debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: emwin_gui_demo.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SKIP_SYSCLK_INIT, CPU_MIMXRT1052DVL6B,XIP_BOOT_HEADER_ENABLE = 1,LV_CONF_INCLUDE_SIMPLE
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;../../..;../../../../../middleware/emwin/emWin_Config;../../../../../middleware/emwin/emWin_header;..;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052;../../../../../devices/MIMXRT1052/utilities/io;../../../../../devices/MIMXRT1052/utilities/str;../../../../../devices/MIMXRT1052/utilities/log;../../../../../devices/MIMXRT1052/utilities;../../../../../devices/MIMXRT1052/xip;..\lvgl;..\lvgl\porting;..\lvgl\src
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_sdram.scf
  link misc: --keep=*(.boot_hdr.ivt)
--keep=*(.boot_hdr.boot_data)
--keep=*(.boot_hdr.dcd_data)
--keep=*(.boot_hdr.conf)
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group main
    ../service/main/: lvgl_demo.c
  group board
    ../board/: pin_mux.c pin_mux.h
  group board-src
    ../board/: board.c clock_config.c
  group doc
    ../: readme.txt
  group fsl_lib
    ../fsl_lib/: fsl_elcdif.c fsl_pxp.c fsl_common.c fsl_clock.c fsl_lpi2c.c fsl_gpio.c fsl_pit.c fsl_iomuxc.h fsl_lpuart.c
  group startup
    ../startup/: system_MIMXRT1052.c system_MIMXRT1052.h startup_MIMXRT1052.s
  group utilities
    ../utilities/io/: fsl_io.c
    ../utilities/log/: fsl_log.c
    ../utilities/str/: fsl_str.c
    ../utilities/: fsl_debug_console.c fsl_assert.c
  group xip
    ../xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
  group lvgl_src_core
    ../lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl_src_draw
    ../lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../lvgl/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../lvgl/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_rect.c lv_gpu_nxp_vglite.c
    ../lvgl/src/draw/nxp/: lv_gpu_nxp.c
    ../lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
  group lvgl_src_extra
    ../lvgl/src/extra/layouts/flex/: lv_flex.c
    ../lvgl/src/extra/layouts/grid/: lv_grid.c
    ../lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../lvgl/src/extra/others/monkey/: lv_monkey.c
    ../lvgl/src/extra/others/msg/: lv_msg.c
    ../lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../lvgl/src/extra/themes/default/: lv_theme_default.c
    ../lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../lvgl/src/extra/widgets/chart/: lv_chart.c
    ../lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../lvgl/src/extra/widgets/led/: lv_led.c
    ../lvgl/src/extra/widgets/list/: lv_list.c
    ../lvgl/src/extra/widgets/menu/: lv_menu.c
    ../lvgl/src/extra/widgets/meter/: lv_meter.c
    ../lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../lvgl/src/extra/widgets/span/: lv_span.c
    ../lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../lvgl/src/extra/widgets/win/: lv_win.c
    ../lvgl/src/extra/: lv_extra.c
  group lvgl_src_font
    ../lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl_src_hal
    ../lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvg_srcl_misc
    ../lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl_src_widgets
    ../lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl_porting
    ../lvgl/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group service/lvgl_demo
    ../service/lvgl_demo/widgets/: lv_demo_widgets.c
    ../service/lvgl_demo/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
  group service/hal
    ../service/hal/: fsl_ft5406_rt.c hal_lcd.c
target lvgl_demo flexspi_nor_debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: emwin_gui_demo.out +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SKIP_SYSCLK_INIT, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, CPU_MIMXRT1052DVL6B,LV_CONF_INCLUDE_SIMPLE,
  c misc: as above
  c include: ..\CMSIS\Include;../../../../../devices;../../..;..\board;..;..\fsl_lib;..\startup;..\utilities\io;..\utilities\log;..\utilities\str;..\utilities;..\xip;..\lvgl\src;..\lvgl;..\lvgl\porting;..\service\lvgl_demo;..\service\lvgl_demo\widgets;..\service\lvgl_demo\widgets\assets;..\service\hal
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\scf\MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: --remove 
--keep=*(.boot_hdr.ivt) 
--keep=*(.boot_hdr.boot_data) 
--keep=*(.boot_hdr.dcd_data) 
--keep=*(.boot_hdr.conf) 
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
target lvgl_demo sdram_release (ARM-ADS)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: emwin_gui_demo.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SKIP_SYSCLK_INIT, CPU_MIMXRT1052DVL6B
  c misc: as above
  c include: ../../../../../CMSIS/Include;../../../../../devices;../../..;../../../../../middleware/emwin/emWin_Config;../../../../../middleware/emwin/emWin_header;..;../../../../../devices/MIMXRT1052/drivers;../../../../../devices/MIMXRT1052;../../../../../devices/MIMXRT1052/utilities/io;../../../../../devices/MIMXRT1052/utilities/str;../../../../../devices/MIMXRT1052/utilities/log;../../../../../devices/MIMXRT1052/utilities;../../../../../devices/MIMXRT1052/xip
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_sdram.scf
  link misc: ../../../../../middleware/emwin/emWin_library/Keil/emWin_M4F.lib 
--remove
target lvgl_demo flexspi_nor_release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: emwin_gui_demo.out
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SKIP_SYSCLK_INIT, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, CPU_MIMXRT1052DVL6B
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: ../../../../../middleware/emwin/emWin_library/Keil/emWin_M4F.lib 
--remove 
--keep=*(.boot_hdr.ivt) 
--keep=*(.boot_hdr.boot_data) 
--keep=*(.boot_hdr.dcd_data) 
--keep=*(.boot_hdr.conf) 
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
